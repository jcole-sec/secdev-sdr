options:
  parameters:
    generate_options: qt_gui
    id: uhd_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '88500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
